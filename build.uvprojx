# Keil uVision project build.uvprojx, settings and files
target APP (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F429ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ZL-B810_APP_MAIN_V0.bin +hex
  AfterMake: fromelf.exe --bin -o "$P@L.bin" "#L"
  AfterMake: mkfw.exe $P@L.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: Sources\cpu;Sources\cpu\cmsis;Sources\cpu\lib;Sources\driver;Sources\kernel;Sources\debug;Sources\main;Sources\common;Sources\modem;Sources\storage;Sources\protect;Sources\client;Sources\module;Sources\service;.\Sources\autonav
  memory RVCT4: ROM 0x8080000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group main
    Sources/main/: app.c bsp.c main.c
  group autonav
    ./Sources/autonav/: auto_boat.c auto_boat_cruise.c auto_dist.c auto_location.c auto_pid.c
  group client
    ./Sources/client/: bizp.c bizp_client.c
  group service
    ./Sources/service/: svc_daemon.c svc_hmi.c svc_dist.c svc_485.c svc_auto.c svc_mpu9250.c svc_hittest.c svc_compass.c svc_gnss.c svc_wqdet.c svc_sail.c
  group modem
    ./Sources/modem/: atcmd.c ec20.c modem.c
  group storage
    ./Sources/storage/: appcfg.c dfu.c track.c xgfw.c
    Sources/storage/: syscfg.c
  group module
    ./Sources/module/: dist.c hmi.c rs485.c sail.c feed.c batt.c gnss.c water.c
  group protect
    Sources/protect/: gt102.c protect.c sha256.c
  group common
    Sources/common/: cJSON.c fifo.c ftp.c http.c md5.c mpool.c des.c mac.c
    ./Sources/common/: binconv.c crc.c filter.c mqtt.c base64.c
  group debug
    ./Sources/debug/: fault.c log.c serial.c
  group driver
    Sources/driver/: board.c sdram.c wdog.c nvic.c gpio.c time.c uart.c irom.c i2c.c spi.c rtc.c beep.c w25qxx.c
    ./Sources/driver/: uuid.c led.c lm75.c mpu9250.c delay.c
  group kernel
    Sources/kernel/: port.c kernel.lib
  group cpu/lib
    Sources/cpu/lib/: STM32F429.lib
  group cpu
    Sources/cpu/: startup_stm32f429_439xx.s system_stm32f4xx.c
